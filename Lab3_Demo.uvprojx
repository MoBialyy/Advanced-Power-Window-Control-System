# Keil uVision project Lab3_Demo.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c include: C:\ti\TivaWare_C_Series-2.2.0.295\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: basic_io.c consoleprint.c main.c retarget.c ports_init.h ports_init.c lcd.h lcd.c
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/: sysctl.h gpio.h interrupt.h
  group New Group
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 11.1.0, RTOS:Core 11.1.0, RTOS:Event Groups 11.1.0, RTOS:Heap 11.1.0, RTOS:Timers 11.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.1.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.1
